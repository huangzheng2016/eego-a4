// SPDX-License-Identifier: GPL-3.0-or-later
// fallback_font.cpp — 内置 5x7 ASCII 回退字体实现
//
// 字形表：0x20..0x5F（空格/标点/数字/大写字母），每字形 5 字节列编码，
// 每字节一列，bit0=顶行 … bit6=底行（7 行有效）。小写映射到大写，
// 其余码点画 .notdef 占位框（空心矩形）。

#include "fallback_font.h"

namespace eego {

namespace {

// .notdef 占位框（空心矩形）
constexpr uint8_t GLYPH_NOTDEF[5] = {0x7F, 0x41, 0x41, 0x41, 0x7F};

// 5x7 字形表（0x20 起，连续至 0x5F）
constexpr uint8_t GLYPHS[64][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00},  // 0x20 空格
    {0x00, 0x00, 0x5F, 0x00, 0x00},  // !
    {0x00, 0x07, 0x00, 0x07, 0x00},  // "
    {0x14, 0x7F, 0x14, 0x7F, 0x14},  // #
    {0x24, 0x2A, 0x7F, 0x2A, 0x12},  // $
    {0x23, 0x13, 0x08, 0x64, 0x62},  // %
    {0x36, 0x49, 0x55, 0x22, 0x50},  // &
    {0x00, 0x05, 0x03, 0x00, 0x00},  // '
    {0x00, 0x1C, 0x22, 0x41, 0x00},  // (
    {0x00, 0x41, 0x22, 0x1C, 0x00},  // )
    {0x14, 0x08, 0x3E, 0x08, 0x14},  // *
    {0x08, 0x08, 0x3E, 0x08, 0x08},  // +
    {0x00, 0x50, 0x30, 0x00, 0x00},  // ,
    {0x08, 0x08, 0x08, 0x08, 0x08},  // -
    {0x00, 0x60, 0x60, 0x00, 0x00},  // .
    {0x20, 0x10, 0x08, 0x04, 0x02},  // /
    {0x3E, 0x51, 0x49, 0x45, 0x3E},  // 0
    {0x00, 0x42, 0x7F, 0x40, 0x00},  // 1
    {0x42, 0x61, 0x51, 0x49, 0x46},  // 2
    {0x21, 0x41, 0x45, 0x4B, 0x31},  // 3
    {0x18, 0x14, 0x12, 0x7F, 0x10},  // 4
    {0x27, 0x45, 0x45, 0x45, 0x39},  // 5
    {0x3C, 0x4A, 0x49, 0x49, 0x30},  // 6
    {0x01, 0x71, 0x09, 0x05, 0x03},  // 7
    {0x36, 0x49, 0x49, 0x49, 0x36},  // 8
    {0x06, 0x49, 0x49, 0x29, 0x1E},  // 9
    {0x00, 0x36, 0x36, 0x00, 0x00},  // :
    {0x00, 0x56, 0x36, 0x00, 0x00},  // ;
    {0x08, 0x14, 0x22, 0x41, 0x00},  // <
    {0x14, 0x14, 0x14, 0x14, 0x14},  // =
    {0x00, 0x41, 0x22, 0x14, 0x08},  // >
    {0x02, 0x01, 0x51, 0x09, 0x06},  // ?
    {0x32, 0x49, 0x79, 0x41, 0x3E},  // @
    {0x7E, 0x11, 0x11, 0x11, 0x7E},  // A
    {0x7F, 0x49, 0x49, 0x49, 0x36},  // B
    {0x3E, 0x41, 0x41, 0x41, 0x22},  // C
    {0x7F, 0x41, 0x41, 0x22, 0x1C},  // D
    {0x7F, 0x49, 0x49, 0x49, 0x41},  // E
    {0x7F, 0x09, 0x09, 0x09, 0x01},  // F
    {0x3E, 0x41, 0x49, 0x49, 0x7A},  // G
    {0x7F, 0x08, 0x08, 0x08, 0x7F},  // H
    {0x00, 0x41, 0x7F, 0x41, 0x00},  // I
    {0x20, 0x40, 0x41, 0x3F, 0x01},  // J
    {0x7F, 0x08, 0x14, 0x22, 0x41},  // K
    {0x7F, 0x40, 0x40, 0x40, 0x40},  // L
    {0x7F, 0x02, 0x0C, 0x02, 0x7F},  // M
    {0x7F, 0x04, 0x08, 0x10, 0x7F},  // N
    {0x3E, 0x41, 0x41, 0x41, 0x3E},  // O
    {0x7F, 0x09, 0x09, 0x09, 0x06},  // P
    {0x3E, 0x41, 0x51, 0x21, 0x5E},  // Q
    {0x7F, 0x09, 0x19, 0x29, 0x46},  // R
    {0x46, 0x49, 0x49, 0x49, 0x31},  // S
    {0x01, 0x01, 0x7F, 0x01, 0x01},  // T
    {0x3F, 0x40, 0x40, 0x40, 0x3F},  // U
    {0x1F, 0x20, 0x40, 0x20, 0x1F},  // V
    {0x3F, 0x40, 0x38, 0x40, 0x3F},  // W
    {0x63, 0x14, 0x08, 0x14, 0x63},  // X
    {0x07, 0x08, 0x70, 0x08, 0x07},  // Y
    {0x61, 0x51, 0x49, 0x45, 0x43},  // Z
    {0x00, 0x7F, 0x41, 0x41, 0x00},  // [
    {0x02, 0x04, 0x08, 0x10, 0x20},  // \ 反斜杠
    {0x00, 0x41, 0x41, 0x7F, 0x00},  // ]
    {0x04, 0x02, 0x01, 0x02, 0x04},  // ^
    {0x40, 0x40, 0x40, 0x40, 0x40},  // _ 下划线
};

// 取字符字形：ASCII 直接映射（小写→大写），其余返回占位框
const uint8_t* glyphFor(uint32_t codepoint) {
    if (codepoint >= 'a' && codepoint <= 'z') {
        codepoint -= ('a' - 'A');
    }
    if (codepoint >= 0x20 && codepoint <= 0x5F) {
        return GLYPHS[codepoint - 0x20];
    }
    return GLYPH_NOTDEF;
}

// UTF-8 解码下一个码点（非法序列按单字节占位处理并推进 1 字节）
uint32_t nextCodepoint(const uint8_t*& p) {
    uint32_t c = *p++;
    if (c < 0x80) return c;
    if ((c & 0xE0) == 0xC0 && (*p & 0xC0) == 0x80) {
        c = ((c & 0x1F) << 6) | (*p++ & 0x3F);
        return c;
    }
    if ((c & 0xF0) == 0xE0 && (p[0] & 0xC0) == 0x80 && (p[1] & 0xC0) == 0x80) {
        c = ((c & 0x0F) << 12) | ((p[0] & 0x3F) << 6) | (p[1] & 0x3F);
        p += 2;
        return c;
    }
    if ((c & 0xF8) == 0xF0 && (p[0] & 0xC0) == 0x80 && (p[1] & 0xC0) == 0x80 &&
        (p[2] & 0xC0) == 0x80) {
        c = ((c & 0x07) << 18) | ((p[0] & 0x3F) << 12) | ((p[1] & 0x3F) << 6) |
            (p[2] & 0x3F);
        p += 3;
        return c;
    }
    return 0xFFFD;  // 非法序列：占位
}

void drawGlyph(PortraitCanvas& canvas, int16_t x, int16_t y, const uint8_t* glyph,
               int16_t scale, uint8_t gray) {
    for (int16_t col = 0; col < FALLBACK_GLYPH_W; col++) {
        const uint8_t bits = glyph[col];
        for (int16_t row = 0; row < FALLBACK_GLYPH_H; row++) {
            if (!((bits >> row) & 1)) continue;
            const int16_t px = x + col * scale;
            const int16_t py = y + row * scale;
            if (gray == 0) {
                if (scale == 1) {
                    canvas.drawPixel(px, py, 0);
                } else {
                    canvas.fillRect(px, py, scale, scale, 0);
                }
            } else {
                for (int16_t sy = 0; sy < scale; sy++)
                    for (int16_t sx = 0; sx < scale; sx++)
                        canvas.drawPixelGray(px + sx, py + sy, gray);
            }
        }
    }
}

}  // namespace

int16_t fallbackTextWidth(const char* utf8, int16_t scale) {
    if (!utf8 || scale < 1) return 0;
    int16_t chars = 0;
    const uint8_t* p = reinterpret_cast<const uint8_t*>(utf8);
    while (*p) {
        nextCodepoint(p);
        chars++;
    }
    return chars * FALLBACK_ADVANCE * scale;
}

int16_t fallbackDrawText(PortraitCanvas& canvas, int16_t x, int16_t y,
                         const char* utf8, int16_t scale, uint8_t gray) {
    if (!utf8) return x;
    if (scale < 1) scale = 1;
    if (gray > 15) gray = 15;
    int16_t cx = x;
    const uint8_t* p = reinterpret_cast<const uint8_t*>(utf8);
    while (*p) {
        const uint32_t cp = nextCodepoint(p);
        drawGlyph(canvas, cx, y, glyphFor(cp), scale, gray);
        cx += FALLBACK_ADVANCE * scale;
    }
    return cx;
}

}  // namespace eego
